FILESEXTRAPATHS:prepend := "${THISDIR}/${MACHINE}:"