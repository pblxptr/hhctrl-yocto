DESCRIPTION = "Boost library"

BOOST_LIBS += "json"